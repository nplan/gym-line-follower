Commit message: various changes

File: gym_line_follower/follower_bot.urdf (robot description, URDF)
Before this commit: robot follower, 5 links, 4 joints
Links:
- link caster: mass 0.01 -> 0.001
- link chassis: mass 0.3 -> 0.290
